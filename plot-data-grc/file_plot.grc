options:
  parameters:
    generate_options: qt_gui
    id: file_plot
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: nsamps_to_plot
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 3e9
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    length: nsamps_to_plot
    repeat: 'False'
    type: short
    vlen: '2'
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    length: nsamps_to_plot
    repeat: 'False'
    type: short
    vlen: '2'
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    length: nsamps_to_plot
    repeat: 'False'
    type: short
    vlen: '2'
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    length: nsamps_to_plot
    repeat: 'False'
    type: short
    vlen: '2'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0_2
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'True'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0_2_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'True'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0_2_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'True'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0_2_1
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'True'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: nsamps_to_plot
    grid: 'True'
    gui_hint: 2,1
    type: complex
    ymax: '96'
    ymin: '-96'
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: nsamps_to_plot
    grid: 'True'
    gui_hint: 2,0
    type: complex
    ymax: '96'
    ymin: '-96'
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: nsamps_to_plot
    grid: 'True'
    gui_hint: 3,0
    type: complex
    ymax: '96'
    ymin: '-96'
  states: {}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: nsamps_to_plot
    grid: 'True'
    gui_hint: 3,1
    type: complex
    ymax: '96'
    ymin: '-96'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,1
    label1: ''
    label2: ''
    name: '"File B Time Plot"'
    size: nsamps_to_plot
    srate: samp_rate
    type: complex
    ymax: '33000'
    ymin: '-33000'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,0
    label1: ''
    label2: ''
    name: '"File A Time Plot"'
    size: nsamps_to_plot
    srate: samp_rate
    type: complex
    ymax: '33000'
    ymin: '-33000'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0
    label1: ''
    label2: ''
    name: '"File C Time Plot"'
    size: nsamps_to_plot
    srate: samp_rate
    type: complex
    ymax: '33000'
    ymin: '-33000'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,1
    label1: ''
    label2: ''
    name: '"File D Time Plot"'
    size: nsamps_to_plot
    srate: samp_rate
    type: complex
    ymax: '33000'
    ymin: '-33000'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0_0_2, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0_0_2_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_interleaved_short_to_complex_0_0_2_0_0, '0']
- [blocks_file_source_0_1, '0', blocks_interleaved_short_to_complex_0_0_2_1, '0']
- [blocks_interleaved_short_to_complex_0_0_2, '0', blocks_throttle_0, '0']
- [blocks_interleaved_short_to_complex_0_0_2_0, '0', blocks_throttle_0_0, '0']
- [blocks_interleaved_short_to_complex_0_0_2_0_0, '0', blocks_throttle_0_0_0, '0']
- [blocks_interleaved_short_to_complex_0_0_2_1, '0', blocks_throttle_0_1, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_throttle_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle_0_0_0, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [blocks_throttle_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_throttle_0_1, '0', qtgui_freq_sink_x_0_0_1, '0']
- [blocks_throttle_0_1, '0', qtgui_time_sink_x_0_1, '0']

metadata:
  file_format: 1
