options:
  parameters:
    generate_options: qt_gui
    id: Polyphase_resampler
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: int(1.09e9)
  states: {}
- name: fs
  id: variable
  parameters:
    value: int(3.25e6)
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '1.0'
    vector_output: 'True'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/jade/tmp/ramfs-dump1090/sc16-to-adsb.fifo
    type: short
    vlen: '2'
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'True'
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 2.4/3.25
    type: ccf
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: 18e3
    center_freq0: fc
    dc_offs_enb0: '""'
    gain0: '127'
    iq_imbal_enb0: '""'
    otw: sc16
    samp_rate: fs
    stream_args: sc16
    stream_chans: '[0]'
    sync: pc_clock
    type: sc16
  states: {}

connections:
- [blocks_complex_to_interleaved_short_0, '0', blocks_file_sink_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', pfb_arb_resampler_xxx_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [uhd_usrp_source_0, '0', blocks_interleaved_short_to_complex_0, '0']

metadata:
  file_format: 1
