options:
  parameters:
    author: Victor Wollesen
    category: Custom
    description: Vaunt Dual Channel FM Reciever QT GUI
    generate_options: qt_gui
    id: vaunt_dual_qt
    max_nouts: '160000'
    output_language: python
    title: Dual Channel FM Reciever
  states: {}

blocks:
- name: adc_rate
  id: variable
  parameters:
    value: '325000000'
  states: {}
- name: aud_decim_A1
  id: variable
  parameters:
    value: int(round(chan_sr_in_demod_A1/audio_sample_rate))
  states: {}
- name: aud_decim_A2
  id: variable
  parameters:
    value: int(round(chan_sr_in_demod_A2/audio_sample_rate))
  states: {}
- name: aud_sr_1
  id: variable_qtgui_label
  parameters:
    label: Aud SR (1)
    type: int
    value: chan_sr_out_A1
  states: {}
- name: chan_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Channel 1
    start: 87.9e6
    step: 0.2e6
    stop: 107.9e6
    value: 99.9e6
  states: {}
- name: chan_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,1,1,1
    label: Channel 2
    start: 87.9e6
    step: 0.2e6
    stop: 107.9e6
    value: 94.1e6
  states: {}
- name: chan_sr_in_demod_A1
  id: variable
  parameters:
    value: int(round(adc_rate/(source_decim*filt_decim_A1)))
  states: {}
- name: chan_sr_in_demod_A2
  id: variable
  parameters:
    value: int(round(adc_rate/(source_decim*filt_decim_A1)))
  states: {}
- name: chan_sr_out_A1
  id: variable
  parameters:
    value: int(round(chan_sr_in_demod_A1/aud_decim_A1))
  states: {}
- name: chan_width
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Channel Width
    start: 50e3
    step: 1e3
    stop: 1e6
    value: 200e3
  states: {}
- name: chan_xlate_A
  id: variable
  parameters:
    value: chan_1-freq
  states: {}
- name: chan_xlate_A2
  id: variable
  parameters:
    value: chan_2-freq
  states: {}
- name: demod_sr_C1
  id: variable_qtgui_label
  parameters:
    label: Demod SR (1)
    type: real
    value: chan_sr_in_demod_A1
  states: {}
- name: filt_decim_A1
  id: variable
  parameters:
    value: int(round(source_rate/chan_width))
  states: {}
- name: filt_decim_A2
  id: variable
  parameters:
    value: int(round(source_rate/chan_width))
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: RF Freq
    type: int
    value: '97500000'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: RF Gain
    start: '0'
    step: '0.25'
    stop: '31.75'
    value: '0'
  states: {}
- name: source_rate
  id: variable
  parameters:
    value: adc_rate/source_decim
  states: {}
- name: vol_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    label: Channel 1 Volume
    start: '0'
    step: '1'
    stop: '11'
    value: '0'
  states: {}
- name: vol_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,1,1,1
    label: Channel 2 Volume
    start: '0'
    step: '1'
    stop: '11'
    value: '0'
  states: {}
- name: vol_div
  id: variable
  parameters:
    value: '10'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: aud_decim_A1
    audio_pass: '20000'
    audio_stop: '22000'
    chan_rate: chan_sr_in_demod_A1
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_fm_demod_cf_1
  id: analog_fm_demod_cf
  parameters:
    audio_decim: aud_decim_A2
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: chan_sr_in_demod_A2
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sample_rate
  id: parameter
  parameters:
    label: Audio Sample Rate
    type: intx
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: plughw:0,0
    num_inputs: '2'
    ok_to_block: 'False'
    samp_rate: audio_sample_rate
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'True'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol_1/vol_div
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol_2/vol_div
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: chan_xlate_A
    decim: filt_decim_A1
    samp_rate: int(round(adc_rate/source_decim))
    taps: firdes.low_pass (1,int(round(adc_rate/source_decim)),75e3,25e3)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: chan_xlate_A2
    decim: filt_decim_A2
    samp_rate: int(round(adc_rate/source_decim))
    taps: firdes.low_pass (1,int(round(adc_rate/source_decim)),75e3,25e3)
    type: ccc
  states: {}
- name: source_decim
  id: parameter
  parameters:
    label: source decimation
    short_id: d
    type: intx
    value: '15'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: freq
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: rf_gain
    iq_imbal_enb0: '""'
    otw: sc16
    samp_rate: source_rate
    stream_args: sc16
    stream_chans: '[0]'
    sync: sync
    type: sc16
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_fm_demod_cf_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', analog_fm_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', analog_fm_demod_cf_1, '0']
- [uhd_usrp_source_0, '0', blocks_interleaved_short_to_complex_0, '0']

metadata:
  file_format: 1
