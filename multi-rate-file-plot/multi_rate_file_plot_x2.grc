options:
  parameters:
    generate_options: qt_gui
    id: file_plot
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: nsamps_to_plot
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 325e6/2
  states: {}
- name: samp_rate_1
  id: variable
  parameters:
    value: 325e6/2
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jade/doug/uhd/src/uhd/host/build/examples/output/rx_1_ch_0.dat
    length: nsamps_to_plot
    repeat: 'False'
    type: short
    vlen: '2'
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/jade/doug/uhd/src/uhd/host/build/examples/output/rx_0_ch_0.dat
    length: nsamps_to_plot
    repeat: 'False'
    type: short
    vlen: '2'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0_2
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'True'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0_2_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'True'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: items
    maximum: nsamps_to_plot
    samples_per_second: samp_rate_0
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    limit: items
    maximum: nsamps_to_plot
    samples_per_second: samp_rate_1
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_0
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_1
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate_0
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate_1
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0_0_2, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0_0_2_0, '0']
- [blocks_interleaved_short_to_complex_0_0_2, '0', blocks_throttle2_0_0, '0']
- [blocks_interleaved_short_to_complex_0_0_2_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_throttle2_0_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.6.0-1-g6a62c345
