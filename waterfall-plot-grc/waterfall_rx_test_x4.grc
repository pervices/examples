options:
  parameters:
    generate_options: qt_gui
    id: simple_rx
    output_language: python
    title: Simple Rx Test
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: int(freq_sel)
  states: {}
- name: freq_sel
  id: variable_qtgui_range
  parameters:
    label: Freq Sel
    start: '0'
    step: 1e6
    stop: 20e9
    value: 50e6
  states: {}
- name: freq_sel
  id: variable
  parameters:
    value: '0'
  states: {state: disabled}
- name: gain
  id: variable
  parameters:
    value: gain_sel
  states: {}
- name: gain_sel
  id: variable_qtgui_range
  parameters:
    label: Gain Sel
    rangeType: int
    start: '-100'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: gain_sel
  id: variable
  parameters:
    value: '40'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 50e6
  states: {}
- name: blocks_interleaved_short_to_complex_0_0_2
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1'
    vector_input: 'True'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0_2_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1'
    vector_input: 'True'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0_2_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1'
    vector_input: 'True'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0_2_0_1
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1'
    vector_input: 'True'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: (1,0,1,2)
    nconnections: '4'
    type: complex
    ymax: '96'
    ymin: '-96'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: (0,0, 1, 2)
    label1: ''
    label2: ''
    label3: ''
    label4: ''
    label5: ''
    label6: ''
    label7: ''
    label8: ''
    name: '"A"'
    nconnections: '4'
    size: '2048'
    srate: samp_rate
    type: complex
    ymax: '20000'
    ymin: '-20000'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '2048'
    gui_hint: (2,0)
    name: '"Ch0"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '2048'
    gui_hint: (2,1)
    name: '"Ch1"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '2048'
    gui_hint: (3,0)
    name: '"Ch2"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '2048'
    gui_hint: (3,1)
    name: '"Ch3"'
    type: complex
  states: {}
- name: uhd_usrp_source_0_0_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    ant1: ''
    ant2: ''
    ant3: ''
    center_freq0: freq
    center_freq1: freq
    center_freq2: freq
    center_freq3: freq
    clock_rate: '0.0'
    clock_source0: internal
    dev_addr: ''
    gain0: gain
    gain1: gain
    gain2: gain
    gain3: gain
    nchan: '4'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    start_time: '5.0'
    stream_args: sc16
    stream_chans: '[0,1,2,3]'
    sync: sync
    type: sc16
  states: {}

connections:
- [blocks_interleaved_short_to_complex_0_0_2, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_interleaved_short_to_complex_0_0_2, '0', qtgui_time_sink_x_0, '0']
- [blocks_interleaved_short_to_complex_0_0_2, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_interleaved_short_to_complex_0_0_2_0, '0', qtgui_freq_sink_x_0_0, '1']
- [blocks_interleaved_short_to_complex_0_0_2_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_interleaved_short_to_complex_0_0_2_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_interleaved_short_to_complex_0_0_2_0_0, '0', qtgui_freq_sink_x_0_0, '2']
- [blocks_interleaved_short_to_complex_0_0_2_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_interleaved_short_to_complex_0_0_2_0_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [blocks_interleaved_short_to_complex_0_0_2_0_1, '0', qtgui_freq_sink_x_0_0, '3']
- [blocks_interleaved_short_to_complex_0_0_2_0_1, '0', qtgui_time_sink_x_0, '3']
- [blocks_interleaved_short_to_complex_0_0_2_0_1, '0', qtgui_waterfall_sink_x_0_0_0_0, '0']
- [uhd_usrp_source_0_0_0, '0', blocks_interleaved_short_to_complex_0_0_2, '0']
- [uhd_usrp_source_0_0_0, '1', blocks_interleaved_short_to_complex_0_0_2_0, '0']
- [uhd_usrp_source_0_0_0, '2', blocks_interleaved_short_to_complex_0_0_2_0_0, '0']
- [uhd_usrp_source_0_0_0, '3', blocks_interleaved_short_to_complex_0_0_2_0_1, '0']

metadata:
  file_format: 1
